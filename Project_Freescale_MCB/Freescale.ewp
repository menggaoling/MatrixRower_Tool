# IAR project Freescale.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKE04Z64xxx4 Freescale MKE04Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: IAR; FRDM_KE06; CPU_KE06
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include; ; ..\JohnsonType\; ..\Freescale_Lib\config_files; ..\Freescale_Lib\common; ..\Freescale_Lib\cpu; ..\Freescale_Lib\cpu\headers; ..\Freescale_Lib\drivers\acmp; ..\Freescale_Lib\drivers\adc; ..\Freescale_Lib\drivers\bme; ..\Freescale_Lib\drivers\crc; ..\Freescale_Lib\drivers\ftm; ..\Freescale_Lib\drivers\gpio; ..\Freescale_Lib\drivers\ics; ..\Freescale_Lib\drivers\iic; ..\Freescale_Lib\drivers\kbi; ..\Freescale_Lib\drivers\nvm; ..\Freescale_Lib\drivers\pit; ..\Freescale_Lib\drivers\PMC; ..\Freescale_Lib\drivers\rtc; ..\Freescale_Lib\drivers\sim; ..\Freescale_Lib\drivers\spi; ..\Freescale_Lib\drivers\uart; ..\Freescale_Lib\drivers\wdog; ..\Freescale_Lib\drivers\pwt; ..\Freescale_Lib\drivers\can; ..\Freescale_Lib\platforms; ..\Midware_BCS; ..\Midware_Digital_01; ..\Midware_ErrorCode_01; ..\Midware_Incline_01; ..\Midware_Led_01; ..\Midware_Motor_01; ..\Midware_Nvflash_01; ..\Midware_PID_01; ..\Midware_RPM_MCB_01; ..\Midware_Safekey_01; ..\Midware_Temp_01; ..\Midware_Timer_01; ..\Midware_Trace_01; ..\Midware_Update_01; ..\Hal_BCS; ..\Hal_Digital_01; ..\Hal_Incline_01; ..\Hal_Led_01; ..\Hal_Motor_01; ..\Hal_Nvflash_01; ..\Hal_RPM_MCB_01; ..\Hal_Safekey_01; ..\Hal_System_02; ..\Hal_Trace_01; ..\Framework_Main_02; ..\Framework_System_02; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Freescale.bin
  ILINK.IlinkOutputFile: Freescale.out
  ILINK.IlinkIcfFile: ..\Freescale_Lib\config files\KE0x_Flash_64K_FlashConfig.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group Framework_02/Framework_Main_02
    ../Framework_Main_02/: Framework_Main_02.c
  group Framework_02/Framework_System_02
    ../Framework_System_02/: Framework_System_02.c
  group Freescale_Lib/common
    ../Freescale_Lib/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h typedef.h uif.c uif.h
  group Freescale_Lib/config files
    ../Freescale_Lib/config files/: KE0x_Flash_64K_FlashConfig.icf
  group Freescale_Lib/cpu
    ../Freescale_Lib/cpu/: arm_cm0.c arm_cm0.h crt0.s start.c start.h sysinit.c sysinit.h system_MKE06Z4.h systick.c systick.h vectors.c vectors.h
  group Freescale_Lib/cpu/headers
    ../Freescale_Lib/cpu/headers/: derivative.h MKE06Z4.h
  group Freescale_Lib/drivers/acmp
    ../Freescale_Lib/drivers/acmp/: acmp.c
  group Freescale_Lib/drivers/adc
    ../Freescale_Lib/drivers/adc/: adc.c
  group Freescale_Lib/drivers/bitband
    ../Freescale_Lib/drivers/bitband/: bitband.h
  group Freescale_Lib/drivers/bme
    ../Freescale_Lib/drivers/bme/: BME.h
  group Freescale_Lib/drivers/can
    ../Freescale_Lib/drivers/can/: mscan.c
  group Freescale_Lib/drivers/crc
    ../Freescale_Lib/drivers/crc/: crc.c
  group Freescale_Lib/drivers/ftm
    ../Freescale_Lib/drivers/ftm/: ftm.c
  group Freescale_Lib/drivers/gpio
    ../Freescale_Lib/drivers/gpio/: gpio.c
  group Freescale_Lib/drivers/ics
    ../Freescale_Lib/drivers/ics/: ics.c
  group Freescale_Lib/drivers/iic
    ../Freescale_Lib/drivers/iic/: i2c.c
  group Freescale_Lib/drivers/kbi
    ../Freescale_Lib/drivers/kbi/: kbi.c
  group Freescale_Lib/drivers/nvm
    ../Freescale_Lib/drivers/nvm/: flash.c
  group Freescale_Lib/drivers/pit
    ../Freescale_Lib/drivers/pit/: pit.c
  group Freescale_Lib/drivers/PMC
    ../Freescale_Lib/drivers/PMC/: pmc.c
  group Freescale_Lib/drivers/pwt
    ../Freescale_Lib/drivers/pwt/: pwt.c
  group Freescale_Lib/drivers/rtc
    ../Freescale_Lib/drivers/rtc/: rtc.c
  group Freescale_Lib/drivers/sim
    ../Freescale_Lib/drivers/sim/: sim.c
  group Freescale_Lib/drivers/spi
    ../Freescale_Lib/drivers/spi/: spi.c
  group Freescale_Lib/drivers/uart
    ../Freescale_Lib/drivers/uart/: uart.c
  group Freescale_Lib/drivers/wdog
    ../Freescale_Lib/drivers/wdog/: wdog.c
  group Freescale_Lib/platforms
    ../Freescale_Lib/platforms/: ke06_config.h
  group Hal/Hal_BCS
    ../Hal_BCS/: Hal_BCS.c
  group Hal/Hal_Digital_01
    ../Hal_Digital_01/: Hal_Digital_01.c
  group Hal/Hal_Incline_01
    ../Hal_Incline_01/: Hal_Incline_01.c
  group Hal/Hal_Led_01
    ../Hal_Led_01/: Hal_Led_01.c
  group Hal/Hal_Motor_01
    ../Hal_Motor_01/: Hal_Motor_01.c
  group Hal/Hal_Nvflash_01
    ../Hal_Nvflash_01/: Hal_Nvflash_01.c
  group Hal/Hal_RPM_MCB_01
    ../Hal_RPM_MCB_01/: Hal_RPM_MCB_01.c
  group Hal/Hal_Safekey_01
    ../Hal_Safekey_01/: Hal_Safekey_01.c
  group Hal/Hal_System_02
    ../Hal_System_02/: Hal_System_02.c
  group Hal/Hal_Trace_01
    ../Hal_Trace_01/: Hal_Trace_01.c
  group JohnsonType
    ../JohnsonType/: iar.h JIStypes.h
  group Midware
    ../: APID.c
  group Midware/Midware_BCS
    ../Midware_BCS/: Midware_BCS.c
  group Midware/Midware_Digital_01
    ../Midware_Digital_01/: Midware_Digital_01.c
  group Midware/Midware_ErrorCode_01
    ../Midware_ErrorCode_01/: Midware_ErrorCode_01.c
  group Midware/Midware_Incline_01
    ../Midware_Incline_01/: Midware_Incline_01.c
  group Midware/Midware_Led_01
    ../Midware_Led_01/: Midware_Led_01.c
  group Midware/Midware_Motor_01
    ../Midware_Motor_01/: Midware_Motor_01.c
  group Midware/Midware_Nvflash_01
    ../Midware_Nvflash_01/: Midware_Nvflash_01.c
  group Midware/Midware_PID_01
    ../Midware_PID_01/: Midware_PID_01.c
  group Midware/Midware_RPM_MCB_01
    ../Midware_RPM_MCB_01/: Midware_RPM_MCB_01.c
  group Midware/Midware_Safekey_01
    ../Midware_Safekey_01/: Midware_Safekey_01.c
  group Midware/Midware_Temp_01
    ../Midware_Temp_01/: Midware_Temp_01.c
  group Midware/Midware_Timer_01
    ../Midware_Timer_01/: Midware_Timer_01.c
  group Midware/Midware_Trace_01
    ../Midware_Trace_01/: Midware_Trace_01.c
  group Midware/Midware_Update_01
    ../Midware_Update_01/: Midware_Update_01.c
