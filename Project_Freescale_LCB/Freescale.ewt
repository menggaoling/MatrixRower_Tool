<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Framework_01</name>
    <group>
      <name>Framework_Main_01</name>
      <file>
        <name>$PROJ_DIR$\..\Framework_main_01\Framework_main_01.c</name>
      </file>
    </group>
    <group>
      <name>Framework_System_01</name>
      <file>
        <name>$PROJ_DIR$\..\Framework_System_01\Framework_System_01.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Freescale_Lib</name>
    <group>
      <name>common</name>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\common\alloc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\common\assert.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\common\assert.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\common\common.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\common\io.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\common\io.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\common\memtest.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\common\memtest.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\common\queue.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\common\queue.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\common\startup.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\common\startup.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\common\typedef.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\common\uif.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\common\uif.h</name>
      </file>
    </group>
    <group>
      <name>config files</name>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\config files\KE0x_Flash_64K_FlashConfig.icf</name>
      </file>
    </group>
    <group>
      <name>cpu</name>
      <group>
        <name>headers</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\cpu\headers\derivative.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\cpu\headers\MKE06Z4.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\cpu\arm_cm0.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\cpu\arm_cm0.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\cpu\crt0.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\cpu\start.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\cpu\start.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\cpu\sysinit.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\cpu\sysinit.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\cpu\system_MKE06Z4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\cpu\systick.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\cpu\systick.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\cpu\vectors.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\cpu\vectors.h</name>
      </file>
    </group>
    <group>
      <name>drivers</name>
      <group>
        <name>acmp</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\drivers\acmp\acmp.c</name>
        </file>
      </group>
      <group>
        <name>adc</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\drivers\adc\adc.c</name>
        </file>
      </group>
      <group>
        <name>bitband</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\drivers\bitband\bitband.h</name>
        </file>
      </group>
      <group>
        <name>bme</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\drivers\bme\BME.h</name>
        </file>
      </group>
      <group>
        <name>can</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\drivers\can\mscan.c</name>
        </file>
      </group>
      <group>
        <name>crc</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\drivers\crc\crc.c</name>
        </file>
      </group>
      <group>
        <name>ftm</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\drivers\ftm\ftm.c</name>
        </file>
      </group>
      <group>
        <name>gpio</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\drivers\gpio\gpio.c</name>
        </file>
      </group>
      <group>
        <name>ics</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\drivers\ics\ics.c</name>
        </file>
      </group>
      <group>
        <name>iic</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\drivers\iic\i2c.c</name>
        </file>
      </group>
      <group>
        <name>kbi</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\drivers\kbi\kbi.c</name>
        </file>
      </group>
      <group>
        <name>nvm</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\drivers\nvm\flash.c</name>
        </file>
      </group>
      <group>
        <name>pit</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\drivers\pit\pit.c</name>
        </file>
      </group>
      <group>
        <name>PMC</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\drivers\PMC\pmc.c</name>
        </file>
      </group>
      <group>
        <name>pwt</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\drivers\pwt\pwt.c</name>
        </file>
      </group>
      <group>
        <name>rtc</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\drivers\rtc\rtc.c</name>
        </file>
      </group>
      <group>
        <name>sim</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\drivers\sim\sim.c</name>
        </file>
      </group>
      <group>
        <name>spi</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\drivers\spi\spi.c</name>
        </file>
      </group>
      <group>
        <name>uart</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\drivers\uart\uart.c</name>
        </file>
      </group>
      <group>
        <name>wdog</name>
        <file>
          <name>$PROJ_DIR$\..\Freescale_Lib\drivers\wdog\wdog.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>platforms</name>
      <file>
        <name>$PROJ_DIR$\..\Freescale_Lib\platforms\ke06_config.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>Hal</name>
    <group>
      <name>Hal_Digital_01</name>
      <file>
        <name>$PROJ_DIR$\..\Hal_Digital_01\Hal_Digital_01.c</name>
      </file>
    </group>
    <group>
      <name>Hal_ECB_01</name>
      <file>
        <name>$PROJ_DIR$\..\Hal_ECB_01\Hal_ECB_01.c</name>
      </file>
    </group>
    <group>
      <name>Hal_Incline_01</name>
      <file>
        <name>$PROJ_DIR$\..\Hal_Incline_01\Hal_Incline_01.c</name>
      </file>
    </group>
    <group>
      <name>Hal_Induction_01</name>
      <file>
        <name>$PROJ_DIR$\..\Hal_Induction_01\Hal_Induction_01.c</name>
      </file>
    </group>
    <group>
      <name>Hal_Led_01</name>
      <file>
        <name>$PROJ_DIR$\..\Hal_Led_01\Hal_Led_01.c</name>
      </file>
    </group>
    <group>
      <name>Hal_MachineType_01</name>
      <file>
        <name>$PROJ_DIR$\..\Hal_MachineType_01\Hal_MachineType_01.c</name>
      </file>
    </group>
    <group>
      <name>Hal_Nvflash_01</name>
      <file>
        <name>$PROJ_DIR$\..\Hal_Nvflash_01\Hal_Nvflash_01.c</name>
      </file>
    </group>
    <group>
      <name>Hal_RPM_01</name>
      <file>
        <name>$PROJ_DIR$\..\Hal_RPM_01\Hal_RPM_01.c</name>
      </file>
    </group>
    <group>
      <name>Hal_System_01</name>
      <file>
        <name>$PROJ_DIR$\..\Hal_System_01\Hal_System_01.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>JohnsonType</name>
    <file>
      <name>$PROJ_DIR$\..\JohnsonType\iar.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\JohnsonType\JIStypes.h</name>
    </file>
  </group>
  <group>
    <name>Midware</name>
    <group>
      <name>Midware_Digtial_01</name>
      <file>
        <name>$PROJ_DIR$\..\Midware_Digital_01\Midware_Digital_01.c</name>
      </file>
    </group>
    <group>
      <name>Midware_ECB_01</name>
      <file>
        <name>$PROJ_DIR$\..\Midware_ECB_01\Midware_ECB_01.c</name>
      </file>
    </group>
    <group>
      <name>Midware_ErrorCode_01</name>
      <file>
        <name>$PROJ_DIR$\..\Midware_ErrorCode_01\Midware_ErrorCode_01.c</name>
      </file>
    </group>
    <group>
      <name>Midware_Incline_01</name>
      <file>
        <name>$PROJ_DIR$\..\Midware_Incline_01\Midware_Incline_01.c</name>
      </file>
    </group>
    <group>
      <name>Midware_Induction_01</name>
      <file>
        <name>$PROJ_DIR$\..\Midware_Induction_01\Midware_Induction_01.c</name>
      </file>
    </group>
    <group>
      <name>Midware_Led_01</name>
      <file>
        <name>$PROJ_DIR$\..\Midware_Led_01\Midware_Led_01.c</name>
      </file>
    </group>
    <group>
      <name>Midware_MachineType_01</name>
      <file>
        <name>$PROJ_DIR$\..\Midware_MachineType_01\Midware_MachineType_01.c</name>
      </file>
    </group>
    <group>
      <name>Midware_Nvflash_01</name>
      <file>
        <name>$PROJ_DIR$\..\Midware_Nvflash_01\Midware_Nvflash_01.c</name>
      </file>
    </group>
    <group>
      <name>Midware_RPM_01</name>
      <file>
        <name>$PROJ_DIR$\..\Midware_RPM_01\Midware_RPM_01.c</name>
      </file>
    </group>
    <group>
      <name>Midware_Timer_01</name>
      <file>
        <name>$PROJ_DIR$\..\Midware_Timer_01\Midware_Timer_01.c</name>
      </file>
    </group>
    <group>
      <name>Midware_Update_01</name>
      <file>
        <name>$PROJ_DIR$\..\Midware_Update_01\Midware_Update_01.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Project_Freescale_LCB</name>
  </group>
</project>


